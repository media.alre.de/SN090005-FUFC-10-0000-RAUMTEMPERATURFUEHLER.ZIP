Properties of the parts of a building model (IFC2X3)

# File
Description: Raumtemperaturfühler, NTC 10K, UP, Abdeckung 50 x 50 mm, reinweiß glänzend, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: SN090005, Raumtemperaturfühler, NTC 10K, UP, Abdeckung 50 x 50 mm, reinweiß glänzend
In: Raum
Description: Unterputz-Raumtemperaturfühler mit innenliegendem Sensor zur Temperaturmessung in Wohn- und Geschäftsräumen. Der Raumtemperaturfühler mit 50 x 50 mm Deckel kann mittels Zwischenrahmen in nahezu alle Schalterprogramme integriert werden.; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: SN090005; ModelLabel: FUFC 10-0000; GlobalTradeItemNumber: 4050528055774; ProductURL: https://alre.de/produkt_SN090005
Pset_Specification - NominalLength: 0.071 m; NominalWidth: 0.071 m; NominalDepth: 0.0435 m; NetWeight: 0.054
Pset_ALRE_ETIM_Properties - Gehäusefarbe: weiß; Mit Gehäuse: yes; Art der Spannungsversorgung: ohne; Umgebungstemperatur: -10; Ausführung des elektrischen Anschlusses: Schraubanschluss; Deckelbefestigung: geschraubt; Explosionsgeschützt: no; Schutzart (IP): IP30; Einsatzgebiet: Raum; Geeignet für Flüssigkeiten: no; Geeignet für Gase: yes; Temperaturmessbereich: -10; Sensorelement innerhalb des Gehäuses: yes; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Sensorelement außerhalb des Gehäuses: no; Sensortyp: NTC, 10K; Gehäusehöhe: 71; Gehäusebreite: 71; Gehäusetiefe: 43.5; Festes Kabel am Sensor: no; Geeignet für Luft: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-SN090005.pdf
